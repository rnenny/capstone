# Repository rnenny/capstone

## KiCad design keyboard-layout-pcb/keyboard-layout.kicad_pcb

Parts:
D1: LED_RCBG; LED_D5.0mm-4_RGB
D2: LED; LED_D5.0mm
D_1, D_2, D_3, D_4, D_5, D_6, D_7, D_8, D_9, D_10: 1N4148; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
J1: Conn_01x06; Pin_Header_Straight_1x06_Pitch2.54mm
J2, J3: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
K_0, K_1, K_2, K_3, K_4, K_5, K_6, K_7, K_8, K_9: KEYSW; MX-1U-NoLED
Q1: IRLB871; TO-220-3_Horizontal
R1: 100; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R2, R3: 22; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R4: 27; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
U1: TSOP384xx; TSOP384
U2: TSMP58000; TSOP384
U3: RFM9xLoRa; RFM9x

Connections:
3V: D1.1, U1.3 (Vs), U2.3 (Vs), U3.2 (3V)
unnamed: D1.2, R1.1
unnamed: D1.3, R2.1
unnamed: D1.4, R3.1
unnamed: D2.1 (K), Q1.2 (D)
unnamed: D2.2 (A), R4.2
unnamed: D_1.2 (A), K_1.2
unnamed: D_2.2 (A), K_2.2
unnamed: D_3.2 (A), K_3.2
unnamed: D_4.2 (A), K_4.2
unnamed: D_5.2 (A), K_5.2
unnamed: D_6.2 (A), K_6.2
unnamed: D_7.2 (A), K_7.2
unnamed: D_8.2 (A), K_8.2
unnamed: D_9.2 (A), K_9.2
unnamed: D_10.2 (A), K_0.2
unnamed: J1.1, U3.16 (io1)
unnamed: J1.2, U3.15 (Tx1)
unnamed: J1.3, U3.14 (Rx0)
unnamed: J1.4, U3.13 (MIS)
unnamed: J1.5, U3.12 (MOS)
unnamed: J1.6, U3.11 (SCK)
unnamed: J2.1, U3.27 (SCL)
unnamed: J2.2, U3.28 (SDA)
unnamed: J3.1, U3.18 (EN)
unnamed: J3.2, U3.19 (USB)
VBAT: R4.1, U3.17 (BAT)
blue: R3.2, U3.26 (~5)
col0: K_0.1, K_2.1, K_4.1, K_6.1, K_8.1, U3.9 (A4)
col1: K_1.1, K_3.1, K_5.1, K_7.1, K_9.1, U3.10 (A5)
green: R2.2, U3.23 (~10)
mFET: Q1.1 (G), U3.22 (11)
pin12: U2.1 (OUT), U3.21 (12)
pin13: U1.1 (OUT), U3.20 (13)
red: R1.2, U3.24 (~9)
row0: D_1.1 (K), D_10.1 (K), U3.5 (A0)
row1: D_2.1 (K), D_3.1 (K), U3.6 (A1)
row2: D_4.1 (K), D_5.1 (K), U3.7 (A2)
row3: D_6.1 (K), D_7.1 (K), U3.8 (A3)
row4: D_8.1 (K), D_9.1 (K), U3.25 (6)

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
Board: 2 copper layers, 50.0 x 196.7 mm, 33 parts (0 on the bottom side), 41 nets.

## Commit log

2019-12-06 added code
2019-12-06 test
2019-12-06 Added code for handling key pressed for remote
2019-12-09 Layout and scematic for PCB
2019-12-09 Updated scematic to releft current operation
2019-12-09 I think I messed this up, but saving anyways. Going back to code.py
2019-12-09 Initialized LED Pin values to remedy wonky stuff
2019-12-09 Added more initialization for IR recievers
2019-12-09 Updated PCB files for KiCad
    Kicad 5.12
2019-12-10 added rest of the keyboard keys to matrix
2019-12-10 added test ir receive and transmit code
2019-12-10 Updated MOSFET footprint and netlist
2019-12-10 Edited a wiring issue, Added Remote Case, Added Key holder for laser engraving
2019-12-10 Cleaned up code, added heartbeat function, added preliminary diagrams
    Added License
2019-12-10 Removed PDF of preliminary diagrams, replaced with PNGs to make readable
2019-12-11 Revert "Updated scematic to releft current operation"
    This reverts commit bc39922ebd05a59e5cfd160ddaddfcfa669e5cef.
2019-12-11 Updated NX .prt files for the remote case. Unsure if updated stls included
2019-12-11 Updated pin intialization and comments for accuracty
2019-12-12 Added flow control; Began adding pwm for LEDs: Moved code2.py ->code.py
2019-12-12 Added updated files for Mx switch keyjig
2019-12-12 Cleaned up code, added code backup, started mapping keys
2019-12-13 filled in rest of device states (0-4), got ir receiving working (tested with phone ir blaster), setup last few key press events
2019-12-14 cleaned up code, refactored, added better comments; moved other files to folder, added references file for links used
